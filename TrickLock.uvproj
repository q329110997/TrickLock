# Keil uVision project TrickLock.uvproj, settings and files
target src (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: TrickLock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group universal
    ./src/universal/: delay.c delay.h macro.h type.c type.h
  group led
    ./src/led/: led.c led.h
  group main
    ./src/: main.c
